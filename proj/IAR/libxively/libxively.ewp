# IAR project libxively.ewp, settings and files
configuration SL_EventLoop (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VG ST STM32F207VG
  ICCARM.CCDefines: XI_PLATFORM_EVENT_LOOP=0; XI_IO_LAYER=0; XI_IO_LAYER_POSIX_COMPAT=2; XI_DEBUG_OUTPUT=0; NO_STDIO_FILESYSTEM=1; CYASSL_IAR_ARM=1; XI_PLATFORM_BASE_FREERTOS; NO_OCSP; HAVE_SNI; XI_SENML_ENABLED; XI_EMBEDDED_TESTS; XI_CONTROL_TOPIC_ENABLED
  ICCARM.CCDiagSuppress: Pa050,Pe546,Pe111
  ICCARM.CCIncludePath2: ..\..\..\src\libxively; ..\..\..\src\libxively\platform\allocator; ..\..\..\src\libxively\event_dispatcher; ..\..\..\src\libxively\platform\xi_thread; ..\..\..\src\libxively\platform\xi_allocator; ..\..\..\src\libxively\platform\event_loop; ..\..\..\src\libxively\platform\xi_control_topic_name; ..\..\..\src\libxively\datastructures; ..\..\..\src\libxively\io; ..\..\..\src\libxively\io\dummy; ..\..\..\src\libxively\mqtt\logic; ..\..\..\src\libxively\mqtt\codec; ..\..\..\src\libxively\control_topic; ..\..\..\src\libxively\io\simplelink; ..\..\..\src\libxively\io\posix; ..\..\..\src\libxively\tls; ..\..\..\src\import\cyassl; $WW_TOPDIR$\xively-iar\osplatform\free-rtos\system\include; $WW_TOPDIR$\xively-iar\hwplatform\hardware\libf6031; $WW_TOPDIR$\xively-iar\hwplatform\hardware\simplelink\include; $WW_TOPDIR$\xively-iar\swstack\macros; $WW_TOPDIR$\xively-iar\osplatform\free-rtos\system\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libxively.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CONFIG=dummy_io-dummy_platform-no_tls; XI_IO_LAYER=1; XI_IO_LAYER_POSIX_COMPAT=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\src\libxively; ..\..\..\src\libxively\platform\allocator; ..\..\..\src\libxively\event_dispatcher; ..\..\..\src\libxively\platform\xi_thread; ..\..\..\src\libxively\datastructures
  ICCARM.CCOptLevel: 3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src/libxively
    $XI_TOPDIR$/src/libxively/: xi_backoff_status_api.c xi_connection_data.c xi_control_topic_name.c xi_data_desc.c xi_debug.c xi_device_credentials.c xi_err.c xi_globals.c xi_helpers.c xi_hosts_list.c xi_io_timeouts.c xi_layer_api.c xi_layer_default_allocators.c xi_time.c xi_tuples.c xively.c
  group src/libxively/control_topic
    $XI_TOPDIR$/src/libxively/control_topic/: xi_control_topic_layer.c
  group src/libxively/datastructures
    $XI_TOPDIR$/src/libxively/datastructures/: xi_heap.c xi_static_vector.c xi_vector.c
  group src/libxively/event_dispatcher
    $XI_TOPDIR$/src/libxively/event_dispatcher/: xi_event_dispatcher.c xi_event_handle.c xi_event_thread_dispatcher.c
  group src/libxively/io/dummy
    $XI_TOPDIR$/src/libxively/io/dummy/: xi_io_dummy_layer.c xi_io_file.c
  group src/libxively/io/posix
    $XI_TOPDIR$/src/libxively/io/posix/: xi_io_file.c xi_io_posix_layer.c
  group src/libxively/io/simplelink
    $XI_TOPDIR$/src/libxively/io/simplelink/: xi_io_file.c xi_io_sl_layer.c
  group src/libxively/mqtt/codec
    $XI_TOPDIR$/src/libxively/mqtt/codec/: xi_mqtt_codec_layer.c xi_mqtt_message.c xi_mqtt_parser.c xi_mqtt_serialiser.c
  group src/libxively/mqtt/logic
    $XI_TOPDIR$/src/libxively/mqtt/logic/: xi_mqtt_logic_layer.c xi_mqtt_logic_layer_data.c xi_mqtt_logic_layer_keepalive_handler.c xi_mqtt_logic_layer_task_helpers.c
  group src/libxively/platform/eventloop
    $XI_TOPDIR$/src/libxively/platform/event_loop/: xi_platform_posix_std_event_loop.h
  group src/libxively/platform/posix_platform/xi_allocator
    $XI_TOPDIR$/src/libxively/platform/posix_platform/xi_allocator/: xi_posix_allocator.c
  group src/libxively/platform/xi_allocator
    $XI_TOPDIR$/src/libxively/platform/xi_allocator/: xi_allocator.h
  group src/libxively/senml
    $XI_TOPDIR$/src/libxively/senml/: xi_senml.c xi_senml_json_serializer.c xi_senml_types.c
  group src/libxively/tls
    $XI_TOPDIR$/src/libxively/tls/: xi_RootCA_list.c xi_tls_layer.c
