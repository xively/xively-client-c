# IAR project libcyassl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VG ST STM32F207VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FREERTOS; HAVE_TLS_EXTENSIONS; HAVE_SNI; NO_WAY_CYASSL_STM32F2; CYASSL_IAR_ARM
  ICCARM.CCDiagSuppress: Pa050,Pa089,Pe177
  ICCARM.CCIncludePath2: ..\..\..\src\import\cyassl; ..\..\..\..\xively-iar\osplatform\free-rtos\system\include; ..\..\..\..\xively-iar\hwplatform\hardware\libf6031; ..\..\..\..\xively-iar\hwplatform/hardware/stlib/STM32F2xx_StdPeriph_Driver/inc; ..\..\..\..\xively-iar\hwplatform/hardware/stlib/CMSIS/Include/; ..\..\..\..\xively-iar\hwplatform/hardware/stlib/CMSIS/Device/ST/STM32F2xx/Include; ..\..\..\..\xively-iar\swstack\macros; ..\..\..\..\xively-iar\osplatform\free-rtos\system\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libcyassl.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ctaocrypt
    $XI_TOPDIR$/src/import/cyassl/ctaocrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c coding.c compress.c des3.c dh.c dsa.c ecc.c ecc_fp.c error.c hc128.c hmac.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c tfm.c wc_port.c wolfcrypt_first.c wolfcrypt_last.c
  group cyassl
    $XI_TOPDIR$/src/import/cyassl/src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
