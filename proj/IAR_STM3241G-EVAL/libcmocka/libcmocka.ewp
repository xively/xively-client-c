# IAR project libcmocka.ewp, settings and files
configuration Debug-dummy-dummy (ARM, debug)
  General.OGChipSelectEditMenu: STM32F417IG ST STM32F417IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: XI_EMBEDDED_TESTS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: $XI_TOPDIR$\xi_client_c\proj\IAR_STM3241G-EVAL\config.h
  ICCARM.CCIncludePath2: $XI_TOPDIR$\xi_client_c\src\import\cmocka\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libcmocka.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group src/libcmocka
    $XI_TOPDIR$/xi_client_c/src/import/cmocka/src/: cmocka.c
