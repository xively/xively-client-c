# IAR project libxively.ewp, settings and files
configuration Debug-dummy-dummy (ARM, debug)
  General.OGChipSelectEditMenu: STM32F417IG ST STM32F417IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: $XI_TOPDIR$\xi_client_c\proj\IAR_STM3241G-EVAL\xi_target_dummy_io_dummy_platform_config.h
  ICCARM.CCIncludePath2: $XI_TOPDIR$\xi_client_c\src\libxively; $XI_TOPDIR$\xi_client_c\src\libxively\platform\allocator; $XI_TOPDIR$\xi_client_c\src\libxively\event_dispatcher; $XI_TOPDIR$\xi_client_c\src\libxively\platform\xi_thread; $XI_TOPDIR$\xi_client_c\src\libxively\datastructures; $XI_TOPDIR$\xi_client_c\src\libxively\platform\xi_allocator; $XI_TOPDIR$\xi_client_c\src\libxively\mqtt\codec; $XI_TOPDIR$\xi_client_c\src\libxively\mqtt\logic; $XI_TOPDIR$\xi_client_c\src\libxively\io; $XI_TOPDIR$\xi_client_c\src\libxively\io\dummy; $XI_TOPDIR$\xi_client_c\src\libxively\io\posix; $XI_TOPDIR$\xi_client_c\src\libxively\io\fs; $XI_TOPDIR$\xi_client_c\src\libxively\platform\event_loop; $XI_TOPDIR$\xi_client_c\src\libxively\tls; $XI_TOPDIR$\xi_client_c\src\libxively\control_topic; $XI_TOPDIR$\xi_client_c\src\import\wolfssl; $XI_TOPDIR$\xi_client_c\src\import\protobuf-c\library\protobuf-c; $XI_TOPDIR$\xi_client_c\src\import\protobuf-c\library; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\src\include; $APP_PROJ_INC$; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\system; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\src\include\ipv4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libxively.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug-lwip-ewarm (ARM, debug)
  as the first configuration, except:
  ICCARM.PreInclude: $XI_TOPDIR$\xi_client_c\proj\IAR_STM3241G-EVAL\xi_target_lwip_io_ewarm_platform_config.h
  ICCARM.CCIncludePath2: $XI_TOPDIR$\xi_client_c\src\libxively; $XI_TOPDIR$\xi_client_c\src\libxively\platform\allocator; $XI_TOPDIR$\xi_client_c\src\libxively\event_dispatcher; $XI_TOPDIR$\xi_client_c\src\libxively\platform\xi_thread; $XI_TOPDIR$\xi_client_c\src\libxively\datastructures; $XI_TOPDIR$\xi_client_c\src\libxively\platform\xi_allocator; $XI_TOPDIR$\xi_client_c\src\libxively\mqtt\codec; $XI_TOPDIR$\xi_client_c\src\libxively\mqtt\logic; $XI_TOPDIR$\xi_client_c\src\libxively\io; $XI_TOPDIR$\xi_client_c\src\libxively\io\lwip; $XI_TOPDIR$\xi_client_c\src\libxively\io\posix; $XI_TOPDIR$\xi_client_c\src\libxively\io\fs; $XI_TOPDIR$\xi_client_c\src\libxively\platform\event_loop; $XI_TOPDIR$\xi_client_c\src\libxively\tls; $XI_TOPDIR$\xi_client_c\src\libxively\control_topic; $XI_TOPDIR$\xi_client_c\src\import\wolfssl; $XI_TOPDIR$\xi_client_c\src\import\protobuf-c\library\protobuf-c; $XI_TOPDIR$\xi_client_c\src\import\protobuf-c\library; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\src\include; $CUBE_TOPDIR$\Middlewares\Third_Party\FreeRTOS\Source\include; $CUBE_TOPDIR$\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; $APP_PROJ_INC$; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\system; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\src\include\ipv4
  ICCARM.CCOptLevel: 0
  group src/import/protobuf-c/library
    $XI_TOPDIR$/xi_client_c/src/import/protobuf-c/library/: protobuf-c.c
  group src/libxively
    $XI_TOPDIR$/xi_client_c/src/libxively/: xi_backoff_status_api.c xi_connection_data.c xi_control_topic_name.c xi_data_desc.c xi_debug.c xi_device_credentials.c xi_err.c xi_globals.c xi_handle.c xi_helpers.c xi_hosts_list.c xi_internals.c xi_io_timeouts.c xi_layer_api.c xi_layer_default_allocators.c xi_time.c xi_timed_task.c xi_tuples.c xively.c
  group src/libxively/control_topic
    $XI_TOPDIR$/xi_client_c/src/libxively/control_topic/: xi_control_topic_layer.c
  group src/libxively/datastructures
    $XI_TOPDIR$/xi_client_c/src/libxively/datastructures/: xi_heap.c xi_static_vector.c xi_vector.c
  group src/libxively/event_dispatcher
    $XI_TOPDIR$/xi_client_c/src/libxively/event_dispatcher/: xi_event_dispatcher.c xi_event_handle.c xi_event_thread_dispatcher.c
  group src/libxively/io/dummy
    $XI_TOPDIR$/xi_client_c/src/libxively/io/dummy/: xi_io_dummy_layer.c xi_io_file.c
  group src/libxively/io/fs
    $XI_TOPDIR$/xi_client_c/src/libxively/io/fs/: xi_fs_filenames.c xi_resource_manager.c
  group src/libxively/io/fs/memory
    $XI_TOPDIR$/xi_client_c/src/libxively/io/fs/memory/: xi_fs_memory.c
  group src/libxively/io/posix
    $XI_TOPDIR$/xi_client_c/src/libxively/io/posix/: xi_io_file.c xi_io_posix_layer.c
  group src/libxively/mqtt/codec
    $XI_TOPDIR$/xi_client_c/src/libxively/mqtt/codec/: xi_mqtt_codec_layer.c xi_mqtt_codec_layer_data.c xi_mqtt_message.c xi_mqtt_parser.c xi_mqtt_serialiser.c
  group src/libxively/mqtt/logic
    $XI_TOPDIR$/xi_client_c/src/libxively/mqtt/logic/: xi_mqtt_logic_layer.c xi_mqtt_logic_layer_data.c xi_mqtt_logic_layer_keepalive_handler.c xi_mqtt_logic_layer_task_helpers.c
  group src/libxively/platform/eventloop
    $XI_TOPDIR$/xi_client_c/src/libxively/platform/event_loop/: xi_platform_posix_std_event_loop.h
  group src/libxively/platform/posix_platform/xi_allocator
    $XI_TOPDIR$/xi_client_c/src/libxively/platform/posix_platform/xi_allocator/: xi_posix_allocator.c
  group src/libxively/platform/xi_allocator
    $XI_TOPDIR$/xi_client_c/src/libxively/platform/xi_allocator/: xi_allocator.h
  group src/libxively/protobuf-generated
    $XI_TOPDIR$/xi_client_c/src/libxively/protobuf-generated/: control_topic.pb-c.c
  group src/libxively/tls
    $XI_TOPDIR$/xi_client_c/src/libxively/tls/: xi_RootCA_list.c xi_tls_layer.c
