# IAR project libssl.ewp, settings and files
configuration debug_lwip_io_ewarm_platform (ARM, debug)
  General.OGChipSelectEditMenu: STM32F417IG ST STM32F417IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa050,Pa089,Pe177
  ICCARM.PreInclude: $XI_TOPDIR$\xi_client_c\proj\IAR_STM3241G-EVAL\xi_target_lwip_io_ewarm_platform_config.h
  ICCARM.CCIncludePath2: $XI_TLSDIR$; $CUBE_TOPDIR$\Drivers\STM32F4xx_HAL_Driver\Inc; $CUBE_TOPDIR$j\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; $APP_PROJ_INC$; $CUBE_TOPDIR$\Drivers\CMSIS\Device\ST\STM32F4xx\Include; $CUBE_TOPDIR$\Drivers\BSP\STM324xG_EVAL; $CUBE_TOPDIR$\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libssl.out
  group ssl
    $XI_TOPDIR$/xi_client_c/src/import/$XI_SSLDIR$/src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group xi_crypdir
    $XI_TOPDIR$/xi_client_c/src/import/$XI_SSLDIR$/$XI_CRYPTDIR$/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c coding.c compress.c des3.c dh.c dsa.c ecc.c ecc_fp.c error.c hash.c hc128.c hmac.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c tfm.c wc_port.c
