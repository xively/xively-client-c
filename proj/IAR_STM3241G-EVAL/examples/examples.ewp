# IAR project examples.ewp, settings and files
configuration Debug-dummy-dummy (ARM, debug)
  General.OGChipSelectEditMenu: STM32F417IG ST STM32F417IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: $XI_TOPDIR$\xi_client_c\proj\IAR_STM3241G-EVAL\xi_target_dummy_io_dummy_platform_config.h
  ICCARM.CCIncludePath2: $XI_TOPDIR$\xi_client_c\src\libxively; $XI_TOPDIR$\xi_client_c\src\libxively\platform\allocator; $XI_TOPDIR$\xi_client_c\src\libxively\event_dispatcher; $XI_TOPDIR$\xi_client_c\src\libxively\platform\xi_thread; $XI_TOPDIR$\xi_client_c\src\libxively\datastructures; $XI_TOPDIR$\xi_client_c\src\libxively\platform\xi_allocator; $XI_TOPDIR$\xi_client_c\src\libxively\mqtt\codec; $XI_TOPDIR$\xi_client_c\src\libxively\mqtt\logic; $XI_TOPDIR$\xi_client_c\src\libxively\io; $XI_TOPDIR$\xi_client_c\src\libxively\io\dummy; $XI_TOPDIR$\xi_client_c\src\libxively\io\posix; $XI_TOPDIR$\xi_client_c\src\libxively\io\fs; $XI_TOPDIR$\xi_client_c\src\libxively\platform\event_loop; $XI_TOPDIR$\xi_client_c\src\libxively\tls; $XI_TOPDIR$\xi_client_c\src\libxively\control_topic; $XI_TOPDIR$\xi_client_c\src\libxively\sdk\tls_bsp; $XI_TOPDIR$\xi_client_c\src\import\$XI_CRYPTDIR$; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\src\include; $APP_PROJ_INC$; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\system; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\src\include\ipv4
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libxively.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug-lwip-io-ewarm-platform (ARM, debug)
  as the first configuration, except:
  ICCARM.PreInclude: $XI_TOPDIR$\xi_client_c\proj\IAR_STM3241G-EVAL\xi_target_lwip_io_ewarm_platform_config.h
  ICCARM.CCIncludePath2: $XI_TOPDIR$\xi_client_c\src\libxively; $XI_TOPDIR$\xi_client_c\src\libxively\platform\allocator; $XI_TOPDIR$\xi_client_c\src\libxively\event_dispatcher; $XI_TOPDIR$\xi_client_c\src\libxively\platform\xi_thread; $XI_TOPDIR$\xi_client_c\src\libxively\datastructures; $XI_TOPDIR$\xi_client_c\src\libxively\platform\xi_allocator; $XI_TOPDIR$\xi_client_c\src\libxively\mqtt\codec; $XI_TOPDIR$\xi_client_c\src\libxively\mqtt\logic; $XI_TOPDIR$\xi_client_c\src\libxively\io; $XI_TOPDIR$\xi_client_c\src\libxively\io\dummy; $XI_TOPDIR$\xi_client_c\src\libxively\io\posix; $XI_TOPDIR$\xi_client_c\src\libxively\platform\event_loop; $XI_TOPDIR$\xi_client_c\src\libxively\tls; $XI_TOPDIR$\xi_client_c\src\libxively\io\fs; $XI_TOPDIR$\xi_client_c\src\libxively\control_topic; $XI_TOPDIR$\xi_client_c\src\libxively\sdk\tls_bsp; $XI_TOPDIR$\xi_client_c\src\import\$XI_CRYPTDIR$; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\src\include; $APP_PROJ_INC$; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\system; $CUBE_TOPDIR$\Middlewares\Third_Party\LwIP\src\include\ipv4
  ICCARM.CCOptLevel: 0
  group src/examples
    $XI_TOPDIR$/xi_client_c/src/examples/: commandline.c mqtt_last_will.c mqtt_logic_consumer.c mqtt_logic_example.c mqtt_logic_example_two_contexts.c mqtt_logic_producer.c
